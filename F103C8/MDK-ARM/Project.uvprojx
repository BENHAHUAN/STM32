# Keil uVision project Project.uvprojx, settings and files
target SRP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf -c -o "$L@L.txt" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 v6Lto=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\BSP\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\STM32F10x_DSP_Lib\inc;..\RTX\inc;..\RTX\portable;..\USER;..\RTT;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c RTX_Conf_CM.c includes.h
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_can.c
    ../BSP/: DataScope_DP.C
  group bsp
    ../BSP/src/: bsp_gpio.c bsp.c bsp_i2c.c bsp_dwt.c bsp_SysTick.c
    ../USER/: stm32f10x_it.c usartDriver.c
    ../BSP/: PID.c wdd35d.c bsp_tim_pwm.c Motor_Set.c bsp_Encoder.c BSP_CAN.c
  group DSP
    ../Libraries/STM32F10x_DSP_Lib/src/asm/arm/: fir_stm32.s
    ../Libraries/STM32F10x_DSP_Lib/inc/: stm32_dsp.h
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RTX/Source
    ../RTX/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group RTX/Ports
    ../RTX/portable/: HAL_CM3.c rt_HAL_CM.h SVC_Table.s
